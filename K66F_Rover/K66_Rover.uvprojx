# Keil uVision project K66_Rover.uvprojx, settings and files
target FRDM-K66F (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FN2M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K66_Rover
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\K66F_Rover;.\ros_lib
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source
    ./: main.c
  group Drivers
    ./: QE_Driver.c LEDs.c PIT.c Motor_Driver.c UART.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:Startup 3.0.0
